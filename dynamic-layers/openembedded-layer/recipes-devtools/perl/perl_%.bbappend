do_configure:prepend:class-native() {
    export CC="${BUILD_CC}"
    export LD="${BUILD_LD}"
    export AR="${BUILD_AR}"
}
