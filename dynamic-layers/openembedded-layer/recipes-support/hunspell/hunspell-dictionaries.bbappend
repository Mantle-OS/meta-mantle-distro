SRC_URI = "git://github.com/wooorm/dictionaries.git;branch=main;protocol=https"
BBCLASSEXTEND = "native"

