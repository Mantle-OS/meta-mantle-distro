
FILES:${PN}-staticdev += " \
    ${noarch_libdir}/libwaypp.a \
"
