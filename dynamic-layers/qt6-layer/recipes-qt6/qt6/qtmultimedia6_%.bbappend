PACKAGECONFIG:append:class-target = " vaapi"
