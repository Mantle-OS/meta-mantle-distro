PACKAGECONFIG:append:class-target = " flite"
