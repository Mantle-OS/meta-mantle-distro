PACKAGECONFIG:append:class-target = " jasper mng"
