PACKAGECONFIG:append:class-target = " hunspell"
