PACKAGECONFIG:remove = " qt6"

PACKAGECONFIG[matle_qt6] = "-Dqt=true, -Dqt=false, qtbase6"

PACKAGECONFIG:remove = " matle_qt6"
