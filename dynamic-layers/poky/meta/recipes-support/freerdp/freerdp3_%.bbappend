SYSROOT_DIRS += "${bindir}"
PACKAGECONFIG:append = " lame faad faac openh264"

