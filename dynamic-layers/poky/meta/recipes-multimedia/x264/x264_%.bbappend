
# Circular deal here.
PACKAGECONFIG:remove = "ffmpeg"
