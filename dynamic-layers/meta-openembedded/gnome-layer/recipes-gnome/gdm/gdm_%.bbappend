DEPENDS += " json-glib "
