#FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
#SRC_URI += " file://cross.patch "
