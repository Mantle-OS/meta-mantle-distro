
FILES:${PN} += " \
    ${noarch_libdir}/sysusers.d \
    ${noarch_libdir}/tmpfiles.d \
    ${nonarch_libdir}/systemd/user \
"
