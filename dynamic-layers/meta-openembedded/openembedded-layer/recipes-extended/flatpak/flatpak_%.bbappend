FILES:${PN} += " \
    ${nonarch_libdir}/systemd \
    ${nonarch_libdir}/tmpfiles.d \
    ${nonarch_libdir}/sysusers.d \
"
