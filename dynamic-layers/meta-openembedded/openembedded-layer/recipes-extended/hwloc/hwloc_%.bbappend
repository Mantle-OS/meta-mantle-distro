EXTRA_OECONF:append = " \
    --disable-cuda \
    --disable-opencl \
"
