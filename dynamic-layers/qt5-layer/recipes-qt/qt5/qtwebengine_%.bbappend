PACKAGECONFIG:append:class-target = " proprietary-codecs"
