# for inkscape
BOOST_LIBS:append = " \
    stacktrace \
"
DEPENDS:append = " libbacktrace"
